SRC_URI = "git://github.com/xtacocorex/file_fork_for_carhud.git \
        file://debian-742262.patch \
        file://0001-Add-P-prompt-into-Usage-info.patch \
        file://host-file.patch \
        "

SRCREV = "b66c2c04b102695da892df7ff80e25355fb1439f"