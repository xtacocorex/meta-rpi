RPIFW_SRCREV = "bca4259a6aadb8e6bfc5a353d4d92906dd2fe59c"
RPIFW_DATE = "20160430"
RPIFW_SRC_URI ?= "git://github.com/xtacocorex/rpi_bootfiles_for_carhud_yocto.git;protocol=git;branch=master"

LIC_FILES_CHKSUM = "file://LICENCE.broadcom;md5=4a4d169737c0786fb9482bb6d30401d1"

PR = "r17"
